# Repository planetmbit/KiCAD_LoadSW_OCP_Circuit_v1_2

File README.md:

# KiCAD_LoadSW_OCP_Circuit_v1_2
This is Over Current Protection & Load Switch(w/ Current Sense) Circuit's KiCAD Repository (This belongs to the author and The Ryman Sat Project.)

## KiCad design rsp02_LoadSW_OCP_Circuit_v1_2.kicad_pcb

Parts:
J1, J2, J3, J7, J8, J9, J10, J11, J12, J13, J14: Conn_01x02; TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal
J4, J5, J6: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J15: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
J16: Conn_01x10; TerminalBlock_Phoenix_MKDS-3-10-5.08_1x10_P5.08mm_Horizontal
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19: 0; R_0603_1608Metric

Connections:
/LoadSW_OCP_Attitude/LSWE1: R14.1; also elsewhere on the board
/LoadSW_OCP_Attitude/LSWE2: R15.1; also elsewhere on the board
/LoadSW_OCP_C&DH OBC/LSWE1: R12.1; also elsewhere on the board
/LoadSW_OCP_C&DH OBC/LSWE2: R13.1; also elsewhere on the board
/LoadSW_OCP_Deployment Cover/LSWE1: R16.1; also elsewhere on the board
/LoadSW_OCP_Deployment Cover/LSWE2: R17.1; also elsewhere on the board
/LoadSW_OCP_Mission OBC/LSWE1: R10.1; also elsewhere on the board
/LoadSW_OCP_Mission OBC/LSWE2: R11.1; also elsewhere on the board
/LoadSW_OCP_Nichrome Wire/LSWE1: R18.1; also elsewhere on the board
/LoadSW_OCP_Nichrome Wire/LSWE2: R19.1; also elsewhere on the board
/LoadSW_OCP_RX/LSWE1: R8.1; also elsewhere on the board
/LoadSW_OCP_RX/LSWE2: R9.1; also elsewhere on the board
/LoadSW_OCP_TX PA/LSWE1: R4.1; also elsewhere on the board
/LoadSW_OCP_TX PA/LSWE2: R5.1; also elsewhere on the board
/LoadSW_OCP_TX/LSWE1: R6.1; also elsewhere on the board
/LoadSW_OCP_TX/LSWE2: R7.1; also elsewhere on the board
/Power_Line_3_3V_C: R12.2, R13.2; also elsewhere on the board
/Power_Line_3_3V_RX: R8.2, R9.2; also elsewhere on the board
ASWE_fromIOE: J16.7, R14.2
DCSWE_fromIOE: J16.6, R16.2
GNDA: J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, J11.2, J12.2, J13.2, J14.2, J15.1, J16.1; also elsewhere on the board
Imon_Attde: J15.5; also elsewhere on the board
Imon_CDH: J15.6; also elsewhere on the board
Imon_DplyCvr: J15.4; also elsewhere on the board
Imon_Mission: J15.7; also elsewhere on the board
Imon_NicWire: J15.3; also elsewhere on the board
Imon_RX: J15.8; also elsewhere on the board
Imon_TX: J15.9; also elsewhere on the board
Imon_TXPA: J15.10; also elsewhere on the board
MSWE_fromIOE: J16.8, R10.2
NWSWE_fromIOE: J16.5, R18.2
NWSWE_fromRX: J16.2, R19.2
Power_Attitude: J12.1; also elsewhere on the board
Power_C&DH: J11.1; also elsewhere on the board
Power_DeploymentCover: J13.1; also elsewhere on the board
Power_IN_3_0V: J3.1, R3.1; also elsewhere on the board
Power_IN_3_3V: J2.1, R2.1; also elsewhere on the board
Power_IN_5_0V: J1.1, R1.1; also elsewhere on the board
Power_Mission: J10.1; also elsewhere on the board
Power_Mon_3_0V: J6.1, R3.2
Power_Mon_3_3V: J5.1, R2.2
Power_Mon_5_0V: J4.1, R1.2
Power_NichromeWire: J14.1; also elsewhere on the board
Power_RX: J9.1; also elsewhere on the board
Power_TX: J8.1; also elsewhere on the board
Power_TX_PA: J7.1; also elsewhere on the board
TPASWE_fromIOE: J16.10, R4.2
TXSWE_fromIOE: J16.9, R6.2
TXSWE_fromRX: J16.3, R7.2

Notes on the sheet:
5.0V Output
3.3V Output
OCP : Deactive
LoadSW Deactive
3.0V Output
SW Control from RX
[High Active]
3.0V Input
3.3V Input
5.0V Input

Parts:
C16, C17, C18: 0.1u; C_0603_1608Metric
CR23, CR24, CR25, CR26: 1SS352_H3FT
IC6: OP191GSZ_v2; SOIC-8_3.9x4.9mm_P1.27mm; Manufacturer_Part_Number OP191GSZ
Q19: SISS23DN-T1-GE3; POWERPAK-1212-8; Manufacturer_Part_Number SISS23DN-T1-GE3
Q20: IRF7404; SOIC-8_3.9x4.9mm_P1.27mm
Q21: BC848B; SOT-23; mouser part number 771-BC848B215; digikey description TRANS NPN 30V 0.1A SOT23
R79: 6k; R_0603_1608Metric
R80, R86, R89: 100k; R_0603_1608Metric
R81: 0.05; R_2512_6332Metric
R82: 50k; R_0603_1608Metric
R83: 1000k; R_0603_1608Metric
R84, R87, R88: 10k; R_0603_1608Metric
R85: 1k; R_0603_1608Metric
RV6: 200k; Potentiometer_Bourns_3314G_Vertical
Rh6: 100k; R_0603_1608Metric

Connections:
/LoadSW_OCP_TX/LSWE1: CR25.2 (anode); also elsewhere on the board
/LoadSW_OCP_TX/LSWE2: CR26.2 (anode); also elsewhere on the board
/LoadSW_OCP_TX/Power_Line: CR23.1 (cathode), Q19.1 (S(1)), Q19.2 (S(2)), Q19.3 (S(3)), R81.1, R86.1, RV6.1, RV6.2
/Power_Line_3_3V_TX: C17.1, IC6.7, R79.1, R81.2, R89.1; also elsewhere on the board
GNDA: C16.2, C17.2, IC6.4, Q21.2 (emitter), R80.2, R83.2, R88.2; also elsewhere on the board
unnamed: C16.1, CR23.2 (anode), IC6.2, R82.2, R83.1
unnamed: C18.2, R84.1, R85.2
unnamed: CR24.1 (cathode), Q20.5 (D), Q20.6 (D), Q20.7 (D), Q20.8 (D), R85.1
unnamed: CR24.2 (anode), IC6.6, R84.2, Rh6.1
unnamed: CR25.1 (cathode), CR26.1 (cathode), R87.2
unnamed: IC6.3, R79.2, R80.1, Rh6.2
unnamed: Q19.4 (G), Q20.1 (S), Q20.2 (S), Q20.3 (S), R86.2
unnamed: Q20.4 (G), Q21.3 (collector), R89.2
unnamed: Q21.1 (base), R87.1, R88.1
unnamed: R82.1, RV6.3
Power_TX: C18.1, Q19.5 (D(1)), Q19.6 (D(2)), Q19.7 (D(3)), Q19.8 (D(4)); also elsewhere on the board

Parts of its further copies:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: 0.1u; C_0603_1608Metric
CR1, CR2, CR3, CR4, CR5, CR6, CR7, CR8, CR9, CR10, CR11, CR12, CR13, CR14, CR15, CR16: 1SS352_H3FT
IC1, IC2, IC3, IC4: OP191GSZ_v2; SOIC-8_3.9x4.9mm_P1.27mm; Manufacturer_Part_Number OP191GSZ
Q1, Q4, Q7, Q10: SISS23DN-T1-GE3; POWERPAK-1212-8; Manufacturer_Part_Number SISS23DN-T1-GE3
Q2, Q5, Q8, Q11: IRF7404; SOIC-8_3.9x4.9mm_P1.27mm
Q3, Q6, Q9, Q12: BC848B; SOT-23; mouser part number 771-BC848B215; digikey description TRANS NPN 30V 0.1A SOT23
R20, R31, R42, R53: 6k; R_0603_1608Metric
R21, R27, R30, R32, R38, R41, R43, R49, R52, R54, R60, R63: 100k; R_0603_1608Metric
R22, R33, R44, R55: 0.05; R_2512_6332Metric
R23, R34, R45, R56: 50k; R_0603_1608Metric
R24, R35, R46, R57: 1000k; R_0603_1608Metric
R25, R28, R29, R36, R39, R40, R47, R50, R51, R58, R61, R62: 10k; R_0603_1608Metric
R26, R37, R48, R59: 1k; R_0603_1608Metric
RV1, RV2, RV3, RV4: 200k; Potentiometer_Bourns_3314G_Vertical
Rh1, Rh2, Rh3, Rh4: 100k; R_0603_1608Metric

Connections of its further copies:
/LoadSW_OCP_Attitude/LSWE1: CR15.2 (anode); also elsewhere on the board
/LoadSW_OCP_Attitude/LSWE2: CR16.2 (anode); also elsewhere on the board
/LoadSW_OCP_Attitude/Power_Line: CR13.1 (cathode), Q10.1 (S(1)), Q10.2 (S(2)), Q10.3 (S(3)), R55.1, R60.1, RV4.1, RV4.2
/LoadSW_OCP_C&DH OBC/LSWE1: CR11.2 (anode); also elsewhere on the board
/LoadSW_OCP_C&DH OBC/LSWE2: CR12.2 (anode); also elsewhere on the board
/LoadSW_OCP_C&DH OBC/Power_Line: CR9.1 (cathode), Q7.1 (S(1)), Q7.2 (S(2)), Q7.3 (S(3)), R44.1, R49.1, RV3.1, RV3.2
/LoadSW_OCP_Mission OBC/LSWE1: CR7.2 (anode); also elsewhere on the board
/LoadSW_OCP_Mission OBC/LSWE2: CR8.2 (anode); also elsewhere on the board
/LoadSW_OCP_Mission OBC/Power_Line: CR5.1 (cathode), Q4.1 (S(1)), Q4.2 (S(2)), Q4.3 (S(3)), R33.1, R38.1, RV2.1, RV2.2
/LoadSW_OCP_RX/LSWE1: CR3.2 (anode); also elsewhere on the board
/LoadSW_OCP_RX/LSWE2: CR4.2 (anode); also elsewhere on the board
/LoadSW_OCP_RX/Power_Line: CR1.1 (cathode), Q1.1 (S(1)), Q1.2 (S(2)), Q1.3 (S(3)), R22.1, R27.1, RV1.1, RV1.2
/Power_Line_3_3V_A: C11.1, IC4.7, R53.1, R55.2, R63.1; also elsewhere on the board
/Power_Line_3_3V_C: C8.1, IC3.7, R42.1, R44.2, R52.1; also elsewhere on the board
/Power_Line_3_3V_M: C5.1, IC2.7, R31.1, R33.2, R41.1; also elsewhere on the board
/Power_Line_3_3V_RX: C2.1, IC1.7, R20.1, R22.2, R30.1; also elsewhere on the board
GNDA: C1.2, C2.2, C4.2, C5.2, C7.2, C8.2, C10.2, C11.2, IC1.4, IC2.4, IC3.4, IC4.4, Q3.2 (emitter), Q6.2 (emitter), Q9.2 (emitter), Q12.2 (emitter), R21.2, R24.2, R29.2, R32.2, R35.2, R40.2, R43.2, R46.2, R51.2, R54.2, R57.2, R62.2; also elsewhere on the board
unnamed: C1.1, CR1.2 (anode), IC1.2, R23.2, R24.1
unnamed: C3.2, R25.1, R26.2
unnamed: C4.1, CR5.2 (anode), IC2.2, R34.2, R35.1
unnamed: C6.2, R36.1, R37.2
unnamed: C7.1, CR9.2 (anode), IC3.2, R45.2, R46.1
unnamed: C9.2, R47.1, R48.2
unnamed: C10.1, CR13.2 (anode), IC4.2, R56.2, R57.1
unnamed: C12.2, R58.1, R59.2
unnamed: CR2.1 (cathode), Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), R26.1
unnamed: CR2.2 (anode), IC1.6, R25.2, Rh1.1
unnamed: CR3.1 (cathode), CR4.1 (cathode), R28.2
unnamed: CR6.1 (cathode), Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D), R37.1
unnamed: CR6.2 (anode), IC2.6, R36.2, Rh2.1
unnamed: CR7.1 (cathode), CR8.1 (cathode), R39.2
unnamed: CR10.1 (cathode), Q8.5 (D), Q8.6 (D), Q8.7 (D), Q8.8 (D), R48.1
unnamed: CR10.2 (anode), IC3.6, R47.2, Rh3.1
unnamed: CR11.1 (cathode), CR12.1 (cathode), R50.2
unnamed: CR14.1 (cathode), Q11.5 (D), Q11.6 (D), Q11.7 (D), Q11.8 (D), R59.1
unnamed: CR14.2 (anode), IC4.6, R58.2, Rh4.1
unnamed: CR15.1 (cathode), CR16.1 (cathode), R61.2
unnamed: IC1.3, R20.2, R21.1, Rh1.2
unnamed: IC2.3, R31.2, R32.1, Rh2.2
unnamed: IC3.3, R42.2, R43.1, Rh3.2
unnamed: IC4.3, R53.2, R54.1, Rh4.2
unnamed: Q1.4 (G), Q2.1 (S), Q2.2 (S), Q2.3 (S), R27.2
unnamed: Q2.4 (G), Q3.3 (collector), R30.2
unnamed: Q3.1 (base), R28.1, R29.1
unnamed: Q4.4 (G), Q5.1 (S), Q5.2 (S), Q5.3 (S), R38.2
unnamed: Q5.4 (G), Q6.3 (collector), R41.2
unnamed: Q6.1 (base), R39.1, R40.1
unnamed: Q7.4 (G), Q8.1 (S), Q8.2 (S), Q8.3 (S), R49.2
unnamed: Q8.4 (G), Q9.3 (collector), R52.2
unnamed: Q9.1 (base), R50.1, R51.1
unnamed: Q10.4 (G), Q11.1 (S), Q11.2 (S), Q11.3 (S), R60.2
unnamed: Q11.4 (G), Q12.3 (collector), R63.2
unnamed: Q12.1 (base), R61.1, R62.1
unnamed: R23.1, RV1.3
unnamed: R34.1, RV2.3
unnamed: R45.1, RV3.3
unnamed: R56.1, RV4.3
Power_Attitude: C12.1, Q10.5 (D(1)), Q10.6 (D(2)), Q10.7 (D(3)), Q10.8 (D(4)); also elsewhere on the board
Power_C&DH: C9.1, Q7.5 (D(1)), Q7.6 (D(2)), Q7.7 (D(3)), Q7.8 (D(4)); also elsewhere on the board
Power_Mission: C6.1, Q4.5 (D(1)), Q4.6 (D(2)), Q4.7 (D(3)), Q4.8 (D(4)); also elsewhere on the board
Power_RX: C3.1, Q1.5 (D(1)), Q1.6 (D(2)), Q1.7 (D(3)), Q1.8 (D(4)); also elsewhere on the board

Parts:
CR27, CR28: 1SS352_H3FT
Q22: SISS23DN-T1-GE3; POWERPAK-1212-8; Manufacturer_Part_Number SISS23DN-T1-GE3
Q23: IRF7404; SOIC-8_3.9x4.9mm_P1.27mm
Q24: BC848B; SOT-23; mouser part number 771-BC848B215; digikey description TRANS NPN 30V 0.1A SOT23
R90, R93: 100k; R_0603_1608Metric
R91, R92: 10k; R_0603_1608Metric

Connections:
/LoadSW_OCP_Deployment Cover/LSWE1: CR27.2 (anode); also elsewhere on the board
/LoadSW_OCP_Deployment Cover/LSWE2: CR28.2 (anode); also elsewhere on the board
/Power_Line_3_0V_DplyCvr: Q22.1 (S(1)), Q22.2 (S(2)), Q22.3 (S(3)), R90.1, R93.1; also elsewhere on the board
GNDA: Q23.5 (D), Q23.6 (D), Q23.7 (D), Q23.8 (D), Q24.2 (emitter), R92.2; also elsewhere on the board
unnamed: CR27.1 (cathode), CR28.1 (cathode), R91.2
unnamed: Q22.4 (G), Q23.1 (S), Q23.2 (S), Q23.3 (S), R90.2
unnamed: Q23.4 (G), Q24.3 (collector), R93.2
unnamed: Q24.1 (base), R91.1, R92.1
Power_DeploymentCover: Q22.5 (D(1)), Q22.6 (D(2)), Q22.7 (D(3)), Q22.8 (D(4)); also elsewhere on the board

Parts of its further copies:
CR17, CR18: 1SS352_H3FT
Q13: SISS23DN-T1-GE3; POWERPAK-1212-8; Manufacturer_Part_Number SISS23DN-T1-GE3
Q14: IRF7404; SOIC-8_3.9x4.9mm_P1.27mm
Q15: BC848B; SOT-23; mouser part number 771-BC848B215; digikey description TRANS NPN 30V 0.1A SOT23
R64, R67: 100k; R_0603_1608Metric
R65, R66: 10k; R_0603_1608Metric

Connections of its further copies:
/LoadSW_OCP_Nichrome Wire/LSWE1: CR17.2 (anode); also elsewhere on the board
/LoadSW_OCP_Nichrome Wire/LSWE2: CR18.2 (anode); also elsewhere on the board
/Power_Line_3_0V_NicWire: Q13.1 (S(1)), Q13.2 (S(2)), Q13.3 (S(3)), R64.1, R67.1; also elsewhere on the board
GNDA: Q14.5 (D), Q14.6 (D), Q14.7 (D), Q14.8 (D), Q15.2 (emitter), R66.2; also elsewhere on the board
unnamed: CR17.1 (cathode), CR18.1 (cathode), R65.2
unnamed: Q13.4 (G), Q14.1 (S), Q14.2 (S), Q14.3 (S), R64.2
unnamed: Q14.4 (G), Q15.3 (collector), R67.2
unnamed: Q15.1 (base), R65.1, R66.1
Power_NichromeWire: Q13.5 (D(1)), Q13.6 (D(2)), Q13.7 (D(3)), Q13.8 (D(4)); also elsewhere on the board

Parts:
C13, C14, C15: 0.1u; C_0603_1608Metric
CR19, CR20, CR21, CR22: 1SS352_H3FT
IC5: OP191GSZ_v2; SOIC-8_3.9x4.9mm_P1.27mm; Manufacturer_Part_Number OP191GSZ
Q16: SISS23DN-T1-GE3; POWERPAK-1212-8; Manufacturer_Part_Number SISS23DN-T1-GE3
Q17: IRF7404; SOIC-8_3.9x4.9mm_P1.27mm
Q18: BC848B; SOT-23; mouser part number 771-BC848B215; digikey description TRANS NPN 30V 0.1A SOT23
R68: 5.3k; R_0603_1608Metric
R69, R75, R78: 100k; R_0603_1608Metric
R70: 0.10; R_2512_6332Metric
R71: 50k; R_0603_1608Metric
R72: 1000k; R_0603_1608Metric
R73, R76, R77: 10k; R_0603_1608Metric
R74: 1k; R_0603_1608Metric
RV5: 200k; Potentiometer_Bourns_3314G_Vertical
Rh5: 100k; R_0603_1608Metric

Connections:
/LoadSW_OCP_TX PA/LSWE1: CR21.2 (anode); also elsewhere on the board
/LoadSW_OCP_TX PA/LSWE2: CR22.2 (anode); also elsewhere on the board
/LoadSW_OCP_TX PA/Power_Line: CR19.1 (cathode), Q16.1 (S(1)), Q16.2 (S(2)), Q16.3 (S(3)), R70.1, R75.1, RV5.1, RV5.2
/Power_Line_5_0V_TXPA: C14.1, IC5.7, R68.1, R70.2, R78.1; also elsewhere on the board
GNDA: C13.2, C14.2, IC5.4, Q18.2 (emitter), R69.2, R72.2, R77.2; also elsewhere on the board
unnamed: C13.1, CR19.2 (anode), IC5.2, R71.2, R72.1
unnamed: C15.2, R73.1, R74.2
unnamed: CR20.1 (cathode), Q17.5 (D), Q17.6 (D), Q17.7 (D), Q17.8 (D), R74.1
unnamed: CR20.2 (anode), IC5.6, R73.2, Rh5.1
unnamed: CR21.1 (cathode), CR22.1 (cathode), R76.2
unnamed: IC5.3, R68.2, R69.1, Rh5.2
unnamed: Q16.4 (G), Q17.1 (S), Q17.2 (S), Q17.3 (S), R75.2
unnamed: Q17.4 (G), Q18.3 (collector), R78.2
unnamed: Q18.1 (base), R76.1, R77.1
unnamed: R71.1, RV5.3
Power_TX_PA: C15.1, Q16.5 (D(1)), Q16.6 (D(2)), Q16.7 (D(3)), Q16.8 (D(4)); also elsewhere on the board

Schematic: rsp02_module_CS_3_3V.sch, rsp02_module_Current Sense_3_3V

Parts:
C26: 0.1u; C_0603_1608Metric
IC14: INA199A1DCKT_v2; SOT-363_SC-70-6; Manufacturer_Part_Number INA199A1DCKT
R115, R116: 0; R_0603_1608Metric
R117: 0.02; R_2512_6332Metric

Connections:
/Power_Line_3_3V_TX: R115.2, R117.1; also elsewhere on the board
GNDA: C26.2, IC14.1, IC14.2; also elsewhere on the board
Imon_TX: IC14.6; also elsewhere on the board
unnamed: IC14.4, R116.1
unnamed: IC14.5, R115.1
Power_IN_3_3V: C26.1, IC14.3, R116.2, R117.2; also elsewhere on the board

Parts of its further copies:
C19, C20, C21, C22, C23, C24: 0.1u; C_0603_1608Metric
IC7, IC8, IC9, IC10, IC11, IC12: INA199A1DCKT_v2; SOT-363_SC-70-6; Manufacturer_Part_Number INA199A1DCKT
R94, R95, R97, R98, R100, R101, R103, R104, R106, R107, R109, R110: 0; R_0603_1608Metric
R96, R99, R102, R105, R108, R111: 0.02; R_2512_6332Metric

Connections of its further copies:
/Power_Line_3_0V_DplyCvr: R97.2, R99.1; also elsewhere on the board
/Power_Line_3_0V_NicWire: R94.2, R96.1; also elsewhere on the board
/Power_Line_3_3V_A: R100.2, R102.1; also elsewhere on the board
/Power_Line_3_3V_C: R103.2, R105.1; also elsewhere on the board
/Power_Line_3_3V_M: R106.2, R108.1; also elsewhere on the board
/Power_Line_3_3V_RX: R109.2, R111.1; also elsewhere on the board
GNDA: C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, IC7.1, IC7.2, IC8.1, IC8.2, IC9.1, IC9.2, IC10.1, IC10.2, IC11.1, IC11.2, IC12.1, IC12.2; also elsewhere on the board
Imon_Attde: IC9.6; also elsewhere on the board
Imon_CDH: IC10.6; also elsewhere on the board
Imon_DplyCvr: IC8.6; also elsewhere on the board
Imon_Mission: IC11.6; also elsewhere on the board
Imon_NicWire: IC7.6; also elsewhere on the board
Imon_RX: IC12.6; also elsewhere on the board
unnamed: IC7.4, R95.1
unnamed: IC7.5, R94.1
unnamed: IC8.4, R98.1
unnamed: IC8.5, R97.1
unnamed: IC9.4, R101.1
unnamed: IC9.5, R100.1
unnamed: IC10.4, R104.1
unnamed: IC10.5, R103.1
unnamed: IC11.4, R107.1
unnamed: IC11.5, R106.1
unnamed: IC12.4, R110.1
unnamed: IC12.5, R109.1
Power_IN_3_0V: C19.1, C20.1, IC7.3, IC8.3, R95.2, R96.2, R98.2, R99.2; also elsewhere on the board
Power_IN_3_3V: C21.1, C22.1, C23.1, C24.1, IC9.3, IC10.3, IC11.3, IC12.3, R101.2, R102.2, R104.2, R105.2, R107.2, R108.2, R110.2, R111.2; also elsewhere on the board

Schematic: rsp02_module_CS_5_0V.sch, rsp02_module_Current Sense_5_0V

Parts:
C25: 0.1u
IC13: INA199A1DCKT_v2; SOT65P210X110-6N; Manufacturer_Part_Number INA199A1DCKT
R112, R113: 0
R114: 0.04

Connections:
/Power_Line_5_0V_TXPA: R112.2, R114.1; also elsewhere on the board
GNDA: C25.2, IC13.1, IC13.2; also elsewhere on the board
Imon_TXPA: IC13.6; also elsewhere on the board
unnamed: IC13.4, R113.1
unnamed: IC13.5, R112.1
Power_IN_5_0V: C25.1, IC13.3, R113.2, R114.2; also elsewhere on the board

Board: 2 copper layers, 70.0 x 200.0 mm, 241 parts (0 on the bottom side), 145 nets.

Other parts of the board:
REF1, REF2, REF3, REF4: MountingHole_2.2mm_M2_ISO7380_Pad

Their connections:
GNDA: REF1.1, REF2.1, REF3.1, REF4.1; also elsewhere on the board

File rsp02_LoadSW_OCP_Circuit_v1_2_bom2csv.csv (part):

Reference, Value, Footprint, Datasheet, Description, Manufacturer_Name, Manufacturer_Part_Number, RS Part Number, Supplier_Name, ambient temperature range high, ambient temperature range low, automotive, automotive grade, category, collector base voltage, collector emitter saturation voltage, collector emitter voltage, device class L1, device class L2, device class L3, digikey description, digikey part number, emitter base voltage, footprint url, hFE max, hFE min, hFE testIC, hFE testVce, height, ipc land pattern name, lead free, library id, manufacturer, max collector current, max junction temp, mouser description, mouser part number, number of NPN, number of elements, package, power dissipation, rohs, rthja max, temperature range high, unity gain freq, Height, RS Price/Stock
"R8","0","Resistor_SMD:R_0603_1608Metric","~"
"R9","0","Resistor_SMD:R_0603_1608Metric","~"
"R12","0","Resistor_SMD:R_0603_1608Metric","~"
"R13","0","Resistor_SMD:R_0603_1608Metric","~"
"R7","0","Resistor_SMD:R_0603_1608Metric","~"
"R19","0","Resistor_SMD:R_0603_1608Metric","~"
"R18","0","Resistor_SMD:R_0603_1608Metric","~"
"R16","0","Resistor_SMD:R_0603_1608Metric","~"
"R14","0","Resistor_SMD:R_0603_1608Metric","~"
"R10","0","Resistor_SMD:R_0603_1608Metric","~"
"R6","0","Resistor_SMD:R_0603_1608Metric","~"
"R4","0","Resistor_SMD:R_0603_1608Metric","~"
"R5","0","Resistor_SMD:R_0603_1608Metric","~"
"R11","0","Resistor_SMD:R_0603_1608Metric","~"
"R15","0","Resistor_SMD:R_0603_1608Metric","~"
"R17","0","Resistor_SMD:R_0603_1608Metric","~"
"R1","0","Resistor_SMD:R_0603_1608Metric","~"
"R2","0","Resistor_SMD:R_0603_1608Metric","~"
"R3","0","Resistor_SMD:R_0603_1608Metric","~"
"J1","Conn_01x02","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal","~"
"J2","Conn_01x02","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal","~"
"J3","Conn_01x02","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal","~"
"J7","Conn_01x02","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal","~"
"J15","Conn_01x10","Connector_PinHeader_2.54mm:PinHeader_1x10_P2.54mm_Vertical","~"
"J16","Conn_01x10","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-10-5.08_1x10_P5.08mm_Horizontal","~"
"J4","Conn_01x02","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","~"
"J5","Conn_01x02","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","~"
"J6","Conn_01x02","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","~"
"J8","Conn_01x02","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal","~"
"J9","Conn_01x02","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal","~"
"J10","Conn_01x02","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal","~"
"J11","Conn_01x02","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal","~"
"J12","Conn_01x02","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal","~"
"J13","Conn_01x02","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal","~"
"J14","Conn_01x02","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal","~"
"R24","1000k","Resistor_SMD:R_0603_1608Metric","~"
"C2","0.1u","Capacitor_SMD:C_0603_1608Metric","~"
"R22","0.05","Resistor_SMD:R_2512_6332Metric","~"
"R26","1k","Resistor_SMD:R_0603_1608Metric","~"
"Rh1","100k","Resistor_SMD:R_0603_1608Metric","~"
"C3","0.1u","Capacitor_SMD:C_0603_1608Metric","~"
"R25","10k","Resistor_SMD:R_0603_1608Metric","~"
"R21","100k","Resistor_SMD:R_0603_1608Metric","~"
"C1","0.1u","Capacitor_SMD:C_0603_1608Metric","~"
"Q1","SISS23DN-T1-GE3","mypartsLib:POWERPAK-1212-8","http://www.vishay.com/docs/62852/siss23dn.pdf","Vishay SISS23DN-T1-GE3 P-channel MOSFET Transistor, 27 A, -20 V, 8-Pin PowerPAK 1212","Vishay","SISS23DN-T1-GE3","8141314","RS","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"R27","100k","Resistor_SMD:R_0603_1608Metric","~"
"R30","100k","Resistor_SMD:R_0603_1608Metric","~"
"R29","10k","Resistor_SMD:R_0603_1608Metric","~"
"RV1","200k","Potentiometer_SMD:Potentiometer_Bourns_3314G_Vertical","~"
"Q3","BC848B","Package_TO_SOT_SMD:SOT-23","https://assets.nexperia.com/documents/data-sheet/BC848_SER.pdf","","","","","","+150°C","-65°C","Yes","Grade 0","Trans","30V","200mV","30V","Discrete Semiconductors","Transistors","BJTs","TRANS NPN 30V 0.1A SOT23","1727-4241-1-ND","5V","https://assets.nexperia.com/documents/outline-drawing/SOT23.pdf","450","200","2mA","5V","1.1mm","SOT95P230X100-3","Yes","85bbc30039169e11","Nexperia","100mA","+150°C","BC848 Series 30 V 100 mA SMT NPN General Purpose Transistor - SOT-23","771-BC848B215","1","1","SOT23","250mW","Yes","500K/W","+150°C","100MHz","",""
"CR2","1SS352_H3FT","mypartsLib:1SS352_H3FT","https://toshiba.semicon-storage.com/info/docget.jsp?did=3327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"
"CR1","1SS352_H3FT","mypartsLib:1SS352_H3FT","https://toshiba.semicon-storage.com/info/docget.jsp?did=3327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"
"Q2","IRF7404","Package_SO:SOIC-8_3.9x4.9mm_P1.27mm","http://www.infineon.com/dgdl/irf7404.pdf?fileId=5546d4625336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"
"CR4","1SS352_H3FT","mypartsLib:1SS352_H3FT","https://toshiba.semicon-storage.com/info/docget.jsp?did=3327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"
"CR3","1SS352_H3FT","mypartsLib:1SS352_H3FT","https://toshiba.semicon-storage.com/info/docget.jsp?did=3327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"
"R28","10k","Resistor_SMD:R_0603_1608Metric","~"
"IC1","OP191GSZ_v2","Package_SO:SOIC-8_3.9x4.9mm_P1.27mm","http://uk.rs-online.com/web/p/products/0427284P","Analog Devices OP191GSZ Op Amp, 3MHz Rail-Rail, 3  9 V, 8-Pin SOIC","Analog Devices","OP191GSZ","0427284P","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","1.75","http://uk.rs-online.com/web/p/products/0427284P"
"R20","6k","Resistor_SMD:R_0603_1608Metric","~"
"R23","50k","Resistor_SMD:R_0603_1608Metric","~"
"R35","1000k","Resistor_SMD:R_0603_1608Metric","~"
"C5","0.1u","Capacitor_SMD:C_0603_1608Metric","~"
"R33","0.05","Resistor_SMD:R_2512_6332Metric","~"
"R37","1k","Resistor_SMD:R_0603_1608Metric","~"
"Rh2","100k","Resistor_SMD:R_0603_1608Metric","~"
"C6","0.1u","Capacitor_SMD:C_0603_1608Metric","~"
"R36","10k","Resistor_SMD:R_0603_1608Metric","~"
"R32","100k","Resistor_SMD:R_0603_1608Metric","~"
"C4","0.1u","Capacitor_SMD:C_0603_1608Metric","~"
"Q4","SISS23DN-T1-GE3","mypartsLib:POWERPAK-1212-8","http://www.vishay.com/docs/62852/siss23dn.pdf","Vishay SISS23DN-T1-GE3 P-channel MOSFET Transistor, 27 A, -20 V, 8-Pin PowerPAK 1212","Vishay","SISS23DN-T1-GE3","8141314","RS","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","","",""
"R38","100k","Resistor_SMD:R_0603_1608Metric","~"
"R41","100k","Resistor_SMD:R_0603_1608Metric","~"
"R40","10k","Resistor_SMD:R_0603_1608Metric","~"
"RV2","200k","Potentiometer_SMD:Potentiometer_Bourns_3314G_Vertical","~"
"Q6","BC848B","Package_TO_SOT_SMD:SOT-23","https://assets.nexperia.com/documents/data-sheet/BC848_SER.pdf","","","","","","+150°C","-65°C","Yes","Grade 0","Trans","30V","200mV","30V","Discrete Semiconductors","Transistors","BJTs","TRANS NPN 30V 0.1A SOT23","1727-4241-1-ND","5V","https://assets.nexperia.com/documents/outline-drawing/SOT23.pdf","450","200","2mA","5V","1.1mm","SOT95P230X100-3","Yes","85bbc30039169e11","Nexperia","100mA","+150°C","BC848 Series 30 V 100 mA SMT NPN General Purpose Transistor - SOT-23","771-BC848B215","1","1","SOT23","250mW","Yes","500K/W","+150°C","100MHz","",""
"CR6","1SS352_H3FT","mypartsLib:1SS352_H3FT","https://toshiba.semicon-storage.com/info/docget.jsp?did=3327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"
"CR5","1SS352_H3FT","mypartsLib:1SS352_H3FT","https://toshiba.semicon-storage.com/info/docget.jsp?did=3327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"
"Q5","IRF7404","Package_SO:SOIC-8_3.9x4.9mm_P1.27mm","http://www.infineon.com/dgdl/irf7404.pdf?fileId=5546d4625336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"
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
## Commit log

2020-12-06 Changed Design plan(Module Design)
2020-12-07 Update Design
2020-12-08 Update PCB
2020-12-09 PCB Update
2020-12-12 PCB Design Finished
2020-12-13 before gerber output
2020-12-13 PCB reUpdate
2020-12-13 PCB Manufacturing Final Version
2021-01-04 Update_20210104
2021-02-14 Update from S-MacBookPro
